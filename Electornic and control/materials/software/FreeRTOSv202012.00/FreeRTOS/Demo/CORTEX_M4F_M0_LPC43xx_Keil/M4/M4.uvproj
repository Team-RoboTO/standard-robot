# Keil uVision project M4.uvproj, settings and files
target LPC43xx_M4_FLASH (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: Cortex-M4 FPU ARM
  cpu: CLOCK(12000000) CPUTYPE("Cortex-M4") ESEL ELITTLE FPU2
  output: LPC43xx_M4_FLASH +hex
  AfterMake: fromelf --bin -o "$L@L.bin" "$L@L.axf"
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: CORE_M4
  c misc: --no_allow_fpreg_for_nonfpdata
  c include: ..\system;..\platform;..\..\Common\include;..\M4;..\..\..\Source\include;..\..\..\Source\portable\RVDS\ARM_CM4F;..\platform\M4_PeripheralLibraryFiles
  asm define: NO_CRP EXT_FLASH
  library: MicroLIB
  scatter file: ..\platform\M4_Flash.sct
  link misc: --debug --pad=0xFF
  group System Code
    ../platform/: startup_LPC43xx.s
    ../system/: system_LPC43xx.c core_cm4.c emc_LPC43xx.c scu.c fpu_init.c Hitex_Fast_Startup.c
    ../platform/M4_PeripheralLibraryFiles/: lpc43xx_emc.c
  group Platform
    ../platform/: platform_config.h platform_config.c
  group Application_Source
    ./: main.c ParTest.c RegTest.c FreeRTOSConfig.h
  group FreeRTOS_Source
    ../../../Source/portable/RVDS/ARM_CM4F/: port.c
    ../../../Source/portable/MemMang/: heap_2.c
    ../../../Source/: timers.c list.c queue.c tasks.c
  group Common_Demo_Source
    ../../Common/Minimal/: sp_flop.c BlockQ.c blocktim.c countsem.c death.c dynamic.c flash.c GenQTest.c integer.c PollQ.c recmutex.c semtest.c
  group Peripheral_Library
    ../platform/M4_PeripheralLibraryFiles/: lpc43xx_i2c.c lpc43xx_cgu.c
